# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_Lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_Lib
    ./Fw_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Board
    ./Board/: IERG3810_Buzzer.c IERG3810_KEY.c IERG3810_LED.c IERG3810_Buzzer.h IERG3810_KEY.h IERG3810_LED.h IERG3810_Clock.c IERG3810_USART.c IERG3810_Clock.h IERG3810_USART.h FONT.H CFONT.H IERG3810_TFTLCD.c IERG3810_TFTLCD.h IERG3810_EXTI.c IERG3810_EXTI.h IERG3810_TIM.c IERG3810_TIM.h
  group User
    ./User/: main.c stm32f10x_it.c global.h Board.c calculate.c display.c display_USART.c input.c Board.h calculate.h display.h display_USART.h input.h game.c game.h SFONT.H
